options:
  parameters:
    author: GRCon26 workshop
    comment: |-
      M2k Colorimeter Accessory Board on the digital header. V+ and V- power its op amp. LED riser in J5, photodiode risers in J3 and J4.

      Three colors are measured at the same time, not one after another. Each color is chopped at its own frequency, all three shine through the cuvette together, and one FFT pulls them apart again.

      The three chop frequencies are not round numbers on purpose. 205, 246 and 287 whole cycles fit in a 4096-sample buffer at 100 kS/s, which puts each tone exactly on bin 205, 246 and 287 of a 4096-point FFT at that same rate. Measured on this hardware: the peak lands on its own bin and the phase holds to 0.02 ppm, because the pattern generator and the ADC run off one clock. That is what makes a rectangular window correct here -- there is no leakage to taper away.

      The DIO bit does not switch a color on and off. It steers that color's current between LED riser 0 (J5) and riser 1 (J6). Only J5 is populated, so low is lit and high is dark, and idle_level is high so the LED goes out when the flowgraph stops rather than sitting on white.

      Transmittance is the sample photodiode over the reference photodiode, one number per color. The blank_ variables divide out the fact that the two optical paths were never equal to begin with; re-measure them with bench/colorimeter.py run and an empty cuvette.
    description: Frequency-multiplexed colorimetry on an M2K - three colors chopped at once, separated in one FFT.
    generate_options: qt_gui
    id: m2k_colorimeter
    title: M2K colorimeter - three colors at once
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Both directions. The DIO out and the ADC in share a clock at this rate, which is the whole trick.

      This variable feeds the chop sources, the Goertzels and the plot. The two M2K blocks pick their rate from a dropdown instead, so 100 kS/s is typed out twice more in this file. A variable name in that dropdown does not fail -- it silently reverts to 1 MS/s.
    value: '100000'
  states: {}
- name: nfft
  id: variable
  parameters:
    comment: One buffer, one FFT, one measurement. 41 ms of integration.
    value: '4096'
  states: {}
- name: bin_hz
  id: variable
  parameters:
    comment: 24.4140625 Hz. A whole number of these is a tone that lands on one bin and nowhere else.
    value: samp_rate / nfft
  states: {}
- name: red_bin
  id: variable
  parameters:
    comment: 5004.9 Hz
    value: '205'
  states: {}
- name: green_bin
  id: variable
  parameters:
    comment: 6005.9 Hz
    value: '246'
  states: {}
- name: blue_bin
  id: variable
  parameters:
    comment: 7006.8 Hz
    value: '287'
  states: {}
- name: blank_red
  id: variable
  parameters:
    comment: Sample over reference with nothing in either well. Not 1.0, because the beam splitter does not split evenly and the two photodiodes are not the same part twice.
    value: '1.0053'
  states: {}
- name: blank_green
  id: variable
  parameters:
    value: '0.9757'
  states: {}
- name: blank_blue
  id: variable
  parameters:
    value: '0.9911'
  states: {}
- name: rail_pos
  id: m2k_power_supply
  parameters:
    comment: The board's op amp does nothing without these. No rails looks exactly like no light.
    rail: '''v+'''
    voltage: '5.0'
  states: {}
- name: rail_neg
  id: m2k_power_supply
  parameters:
    rail: '''v-'''
    voltage: '-5.0'
  states: {}
- name: red_chop
  id: analog_sig_source_x
  parameters:
    comment: 'Square, amplitude 1, offset 0: GNU Radio''s short square wave is 0 and 1, which is exactly a DIO line. 205 whole cycles fill the buffer, so the cyclic repeat is seamless.'
    type: short
    samp_rate: samp_rate
    waveform: analog.GR_SQR_WAVE
    freq: red_bin * bin_hz
    amp: '1'
    offset: '0'
  states: {}
- name: green_chop
  id: analog_sig_source_x
  parameters:
    type: short
    samp_rate: samp_rate
    waveform: analog.GR_SQR_WAVE
    freq: green_bin * bin_hz
    amp: '1'
    offset: '0'
  states: {}
- name: blue_chop
  id: analog_sig_source_x
  parameters:
    type: short
    samp_rate: samp_rate
    waveform: analog.GR_SQR_WAVE
    freq: blue_bin * bin_hz
    amp: '1'
    offset: '0'
  states: {}
- name: led
  id: m2k_digital_sink
  parameters:
    comment: 'Pushed once, repeated by the hardware forever. Idle HIGH: the bit steers rather than gates, and only riser J5 exists, so idling low would park all three colors on and leave the LED white.'
    num_lines: '3'
    pin0: '13'
    name0: Red
    pin1: '14'
    name1: Green
    pin2: '15'
    name2: Blue
    sample_rate: '100000'
    buffer_size: nfft
    cyclic: 'True'
    idle_level: '''high'''
  states: {}
- name: photodiodes
  id: m2k_analog_source
  parameters:
    comment: |-
      Channel 1 is the reference path, channel 2 is the sample path. Measured, not assumed: blocking the sample well drops channel 2 to 0.8% and leaves channel 1 at 88%.

      buffer_size is nfft on purpose. Each Goertzel window is then exactly one capture buffer and never straddles two, so no measurement spans whatever gap sits between one buffer and the next.
    ch1_enabled: 'True'
    ch2_enabled: 'True'
    ch1_range: '''high'''
    ch2_range: '''high'''
    sample_rate: '100000'
    buffer_size: nfft
    units: '''volts'''
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    comment: Three spikes per trace. Slide a filter into the sample well and watch one of the sample spikes drop while the reference stays put. Drag-zoom to 5-7 kHz; the rest of the span is empty.
    type: float
    name: '"Both photodiodes"'
    nconnections: '2'
    fftsize: nfft
    wintype: window.WIN_RECTANGULAR
    bw: samp_rate
    label1: Reference
    label2: Sample
    grid: 'True'
    ymax: '0'
  states: {}
- name: ref_red
  id: goertzel_fc
  parameters:
    comment: 'Goertzel is a single-bin DFT: multiply by a reference at one frequency and integrate over 4096 samples. That is a lock-in amplifier, written as three lines of arithmetic.'
    rate: samp_rate
    len: nfft
    freq: red_bin * bin_hz
  states: {}
- name: ref_green
  id: goertzel_fc
  parameters:
    rate: samp_rate
    len: nfft
    freq: green_bin * bin_hz
  states: {}
- name: ref_blue
  id: goertzel_fc
  parameters:
    rate: samp_rate
    len: nfft
    freq: blue_bin * bin_hz
  states: {}
- name: sam_red
  id: goertzel_fc
  parameters:
    rate: samp_rate
    len: nfft
    freq: red_bin * bin_hz
  states: {}
- name: sam_green
  id: goertzel_fc
  parameters:
    rate: samp_rate
    len: nfft
    freq: green_bin * bin_hz
  states: {}
- name: sam_blue
  id: goertzel_fc
  parameters:
    rate: samp_rate
    len: nfft
    freq: blue_bin * bin_hz
  states: {}
- name: ref_red_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: ref_green_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: ref_blue_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sam_red_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sam_green_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sam_blue_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: red_ratio
  id: blocks_divide_xx
  parameters:
    comment: Sample on top, reference underneath. If the reference goes dark this reads inf, which is the correct diagnosis rather than a bug.
    type: float
  states: {}
- name: green_ratio
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blue_ratio
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: transmittance
  id: qtgui_number_sink
  parameters:
    comment: 'factorN carries the blank and the percent together: 100 / blank. An empty beam reads 100.0% and holds it to about 0.06%, which is roughly three decades of usable range.'
    type: float
    name: '"Transmittance"'
    nconnections: '3'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    max: '110'
    label1: Red
    unit1: '%'
    factor1: 100.0 / blank_red
    color1: ("black", "red")
    label2: Green
    unit2: '%'
    factor2: 100.0 / blank_green
    color2: ("black", "green")
    label3: Blue
    unit3: '%'
    factor3: 100.0 / blank_blue
    color3: ("black", "blue")
  states: {}

connections:
- [red_chop, '0', led, '0']
- [green_chop, '0', led, '1']
- [blue_chop, '0', led, '2']
- [photodiodes, '0', spectrum, '0']
- [photodiodes, '1', spectrum, '1']
- [photodiodes, '0', ref_red, '0']
- [photodiodes, '0', ref_green, '0']
- [photodiodes, '0', ref_blue, '0']
- [photodiodes, '1', sam_red, '0']
- [photodiodes, '1', sam_green, '0']
- [photodiodes, '1', sam_blue, '0']
- [ref_red, '0', ref_red_mag, '0']
- [ref_green, '0', ref_green_mag, '0']
- [ref_blue, '0', ref_blue_mag, '0']
- [sam_red, '0', sam_red_mag, '0']
- [sam_green, '0', sam_green_mag, '0']
- [sam_blue, '0', sam_blue_mag, '0']
- [sam_red_mag, '0', red_ratio, '0']
- [ref_red_mag, '0', red_ratio, '1']
- [sam_green_mag, '0', green_ratio, '0']
- [ref_green_mag, '0', green_ratio, '1']
- [sam_blue_mag, '0', blue_ratio, '0']
- [ref_blue_mag, '0', blue_ratio, '1']
- [red_ratio, '0', transmittance, '0']
- [green_ratio, '0', transmittance, '1']
- [blue_ratio, '0', transmittance, '2']

metadata:
  file_format: 1
